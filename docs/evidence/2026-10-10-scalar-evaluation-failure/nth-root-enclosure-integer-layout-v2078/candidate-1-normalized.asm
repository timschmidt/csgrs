0000: push   %rbp
0001: push   %r15
0003: push   %r14
0005: push   %r13
0007: push   %r12
0009: push   %rbx
000a: sub    $0x3a8,%rsp
0011: mov    %ecx,%ebp
0013: mov    %rsi,%r13
0016: mov    %rdi,%rbx
0019: mov    (%rdx),%r14
001c: test   %r14,%r14
001f: je     LOCAL+0x2e::approx_signal+0x2e>
0021: movzbl 0x10(%r14),%eax
0026: test   %al,%al
0028: jne    LOCAL+0x1d0::approx_signal+0x1d0>
002e: mov    %rdx,0x40(%rsp)
0033: data16 data16 data16 mov %fs:0x0,%rax
003f: lea    -0x120(%rax),%r15
0046: movzbl -0x110(%rax),%eax
004d: test   %eax,%eax
004f: jne    LOCAL+0xfd0::approx_signal+0xfd0>
0055: movabs $0x7fffffffffffffff,%rax
005f: mov    (%r15),%rcx
0062: cmp    %rax,%rcx
0065: jae    LOCAL+0x1000::approx_signal+0x1000>
006b: lea    0x1(%rcx),%rax
006f: mov    %rax,(%r15)
0072: mov    0x8(%r15),%rdx
0076: test   %rdx,%rdx
0079: je     LOCAL+0x93::approx_signal+0x93>
007b: nopl   0x0(%rax,%rax,1)
0080: cmpb   $0x0,0x20(%rdx)
0084: jne    LOCAL+0x1cd::approx_signal+0x1cd>
008a: mov    0x18(%rdx),%rdx
008e: test   %rdx,%rdx
0091: jne    LOCAL+0x80::approx_signal+0x80>
0093: mov    %rcx,(%r15)
0096: mov    0x0(%r13),%r12
009a: movzbl 0x10(%r12),%edx
00a0: test   %edx,%edx
00a2: jne    LOCAL+0xc3::approx_signal+0xc3>
00a4: cmpb   $0x1,0x30(%r12)
00aa: jne    LOCAL+0xc3::approx_signal+0xc3>
00ac: movups RIP_ADDRESS(%rip),%xmm0
00b3: movups %xmm0,0x10(%rbx)
00b7: movups RIP_ADDRESS(%rip),%xmm0
00be: jmp    LOCAL+0x26e::approx_signal+0x26e>
00c3: cmp    $0xfff00000,%ebp
00c9: jge    LOCAL+0xdc::approx_signal+0xdc>
00cb: neg    %ebp
00cd: setno  %al
00d0: add    %al,%al
00d2: add    $0xa,%al
00d4: mov    %al,0x8(%rbx)
00d7: jmp    LOCAL+0x1d4::approx_signal+0x1d4>
00dc: cmp    $0x2,%edx
00df: je     LOCAL+0x1f0::approx_signal+0x1f0>
00e5: cmp    $0x1,%edx
00e8: je     LOCAL+0x14f::approx_signal+0x14f>
00ea: test   %edx,%edx
00ec: jne    LOCAL+0x21a::approx_signal+0x21a>
00f2: mov    %rax,(%r15)
00f5: mov    0x8(%r15),%rdx
00f9: test   %rdx,%rdx
00fc: je     LOCAL+0x12a::approx_signal+0x12a>
00fe: mov    %rdx,%rsi
0101: cmpb   $0x0,0x20(%rsi)
0105: jne    LOCAL+0x140::approx_signal+0x140>
0107: mov    0x10(%rsi),%rdi
010b: mov    0x18(%rdi),%rax
010f: nop
0110: test   %rax,%rax
0113: je     LOCAL+0x140::approx_signal+0x140>
0115: lea    -0x1(%rax),%r8
0119: lock cmpxchg %r8,0x18(%rdi)
011f: jne    LOCAL+0x110::approx_signal+0x110>
0121: mov    0x18(%rsi),%rsi
0125: test   %rsi,%rsi
0128: jne    LOCAL+0x101::approx_signal+0x101>
012a: mov    %rcx,(%r15)
012d: add    $0x18,%r12
0131: mov    %rbx,%rdi
0134: mov    %r12,%rsi
0137: jmp    LOCAL+0x1a9::approx_signal+0x1a9>
0139: nopl   0x0(%rax)
0140: movb   $0x1,0x20(%rdx)
0144: mov    0x18(%rdx),%rdx
0148: test   %rdx,%rdx
014b: jne    LOCAL+0x140::approx_signal+0x140>
014d: jmp    LOCAL+0x1cd::approx_signal+0x1cd>
014f: mov    %rax,(%r15)
0152: mov    0x8(%r15),%rdx
0156: test   %rdx,%rdx
0159: je     LOCAL+0x18a::approx_signal+0x18a>
015b: mov    %rdx,%rsi
015e: cmpb   $0x0,0x20(%rsi)
0162: jne    LOCAL+0x1c0::approx_signal+0x1c0>
0164: mov    0x10(%rsi),%rdi
0168: mov    0x18(%rdi),%rax
016c: nopl   0x0(%rax)
0170: test   %rax,%rax
0173: je     LOCAL+0x1c0::approx_signal+0x1c0>
0175: lea    -0x1(%rax),%r8
0179: lock cmpxchg %r8,0x18(%rdi)
017f: jne    LOCAL+0x170::approx_signal+0x170>
0181: mov    0x18(%rsi),%rsi
0185: test   %rsi,%rsi
0188: jne    LOCAL+0x15e::approx_signal+0x15e>
018a: mov    %rcx,(%r15)
018d: lea    RIP_ADDRESS(%rip),%rdi
0194: lea    RIP_ADDRESS(%rip),%r14
019b: mov    %r14,%rsi
019e: call   TARGET<<std::sync::once::Once>::call_once_force::<<std::sync::lazy_lock::LazyLock<num_bigint::bigint::BigInt>>::force::{closure
01a3: mov    %rbx,%rdi
01a6: mov    %r14,%rsi
01a9: mov    %ebp,%edx
01ab: call   TARGET<hyperreal::computable::node::scale_at_precision_ref>
01b0: jmp    LOCAL+0x1db::approx_signal+0x1db>
01b2: data16 data16 data16 data16 cs nopw 0x0(%rax,%rax,1)
01c0: movb   $0x1,0x20(%rdx)
01c4: mov    0x18(%rdx),%rdx
01c8: test   %rdx,%rdx
01cb: jne    LOCAL+0x1c0::approx_signal+0x1c0>
01cd: mov    %rcx,(%r15)
01d0: movb   $0xc,0x8(%rbx)
01d4: movq   $0xffffffffffffffff,(%rbx)
01db: mov    %rbx,%rax
01de: add    $0x3a8,%rsp
01e5: pop    %rbx
01e6: pop    %r12
01e8: pop    %r13
01ea: pop    %r14
01ec: pop    %r15
01ee: pop    %rbp
01ef: ret
01f0: movzbl 0x11(%r12),%esi
01f6: lea    0x210(%rsp),%rdi
01fe: mov    %ebp,%edx
0200: call   TARGET<<hyperreal::computable::node::Computable>::cached_constant_at_precision>
0205: cmpq   $0xffffffffffffffff,0x210(%rsp)
020e: jne    LOCAL+0x25a::approx_signal+0x25a>
0210: movl   $0x0,0xc(%rsp)
0218: jmp    LOCAL+0x27c::approx_signal+0x27c>
021a: mov    0x38(%r12),%rax
021f: test   $0x800,%eax
0224: jne    LOCAL+0x23b::approx_signal+0x23b>
0226: mov    %r13,%rdi
0229: mov    0x40(%rsp),%rsi
022e: call   TARGET<<hyperreal::computable::node::Computable>::ensure_finite_real>
0233: cmp    $0xff,%al
0235: jne    LOCAL+0xd4::approx_signal+0xd4>
023b: lea    0x40(%r12),%rsi
0240: lea    0x210(%rsp),%rdi
0248: mov    %ebp,%edx
024a: call   TARGET<<hyperreal::computable::node::EvaluationCache>::at_precision>
024f: cmpq   $0xffffffffffffffff,0x210(%rsp)
0258: je     LOCAL+0x276::approx_signal+0x276>
025a: movups 0x210(%rsp),%xmm0
0262: movups 0x220(%rsp),%xmm1
026a: movups %xmm1,0x10(%rbx)
026e: movups %xmm0,(%rbx)
0271: jmp    LOCAL+0x1db::approx_signal+0x1db>
0276: mov    $0x1,%al
0278: mov    %eax,0xc(%rsp)
027c: lea    0x10(%r12),%rax
0281: mov    %rax,0x38(%rsp)
0286: movzbl (%rax),%eax
0289: add    $0xffffffdc,%eax
028c: cmp    $0x1a,%eax
028f: ja     LOCAL+0x32b::approx_signal+0x32b>
0295: lea    RIP_ADDRESS(%rip),%rcx
029c: movslq (%rcx,%rax,4),%rax
02a0: add    %rcx,%rax
02a3: jmp    *%rax
02a5: movl   $0x1,0x30(%rsp)
02ad: jmp    LOCAL+0x2cb::approx_signal+0x2cb>
02af: movl   $0x0,0x30(%rsp)
02b7: jmp    LOCAL+0x2cb::approx_signal+0x2cb>
02b9: movl   $0x2,0x30(%rsp)
02c1: jmp    LOCAL+0x2cb::approx_signal+0x2cb>
02c3: movl   $0x3,0x30(%rsp)
02cb: lea    0x18(%r12),%rdi
02d0: call   TARGET<<hyperreal::computable::node::Computable>::half_pi_index_when_real>
02d5: test   $0x1,%al
02d7: je     LOCAL+0x32b::approx_signal+0x32b>
02d9: movzbl %dl,%edi
02dc: movl   $0xff000100,0x210(%rsp)
02e7: cmp    $0x3,%dil
02eb: ja     LOCAL+0x11b4::approx_signal+0x11b4>
02f1: movzbl 0x210(%rsp,%rdi,1),%ecx
02f9: movl   $0xff0001,0x210(%rsp)
0304: movzbl 0x210(%rsp,%rdi,1),%eax
030c: mov    0x30(%rsp),%edx
0310: lea    RIP_ADDRESS(%rip),%rsi
0317: movslq (%rsi,%rdx,4),%rdx
031b: add    %rsi,%rdx
031e: jmp    *%rdx
0320: mov    %ecx,%eax
0322: movsbq %al,%rsi
0326: jmp    LOCAL+0xd04::approx_signal+0xd04>
032b: cmpb   $0x0,0xc(%rsp)
0330: je     LOCAL+0x365::approx_signal+0x365>
0332: lea    0x210(%rsp),%rdi
033a: mov    %r13,%rsi
033d: mov    0x40(%rsp),%rdx
0342: mov    %ebp,%ecx
0344: call   TARGET<<hyperreal::computable::node::Computable>::cached_quadratic_tower_approximation>
0349: mov    0x210(%rsp),%r12
0351: cmp    $0xffffffffffffffff,%r12
0355: je     LOCAL+0xdd2::approx_signal+0xdd2>
035b: cmp    $0xfffffffffffffffe,%r12
035f: jne    LOCAL+0xec8::approx_signal+0xec8>
0365: mov    0x38(%rsp),%rsi
036a: movzbl (%rsi),%eax
036d: cmp    $0xa,%eax
0370: ja     LOCAL+0xddf::approx_signal+0xddf>
0376: mov    $0x430,%ecx
037b: bt     %eax,%ecx
037e: jae    LOCAL+0xddf::approx_signal+0xddf>
0384: movl   $0xffffffff,0x108(%rsp)
038f: movl   $0xffffffff,0x118(%rsp)
039a: movl   $0xffffffff,0x128(%rsp)
03a5: movl   $0xffffffff,0x138(%rsp)
03b0: movl   $0xffffffff,0x148(%rsp)
03bb: movl   $0xffffffff,0x158(%rsp)
03c6: movl   $0xffffffff,0x168(%rsp)
03d1: movl   $0xffffffff,0x178(%rsp)
03dc: movl   $0xffffffff,0x188(%rsp)
03e7: movl   $0xffffffff,0x198(%rsp)
03f2: movl   $0xffffffff,0x1a8(%rsp)
03fd: movl   $0xffffffff,0x1b8(%rsp)
0408: movl   $0xffffffff,0x1c8(%rsp)
0413: movl   $0xffffffff,0x1d8(%rsp)
041e: movl   $0xffffffff,0x1e8(%rsp)
0429: movl   $0xffffffff,0x1f8(%rsp)
0434: movq   $0x0,0x208(%rsp)
0440: movq   $0x0,0xf0(%rsp)
044c: movq   $0x8,0xf8(%rsp)
0458: movq   $0x0,0x100(%rsp)
0464: movq   $0xffffffffffffffff,0x228(%rsp)
0470: movq   $0xffffffffffffffff,0x248(%rsp)
047c: movq   $0xffffffffffffffff,0x268(%rsp)
0488: movq   $0xffffffffffffffff,0x288(%rsp)
0494: movq   $0xffffffffffffffff,0x2a8(%rsp)
04a0: movq   $0xffffffffffffffff,0x2c8(%rsp)
04ac: movq   $0xffffffffffffffff,0x2e8(%rsp)
04b8: movq   $0xffffffffffffffff,0x308(%rsp)
04c4: movq   $0x0,0x328(%rsp)
04d0: movq   $0x0,0x210(%rsp)
04dc: movq   $0x8,0x218(%rsp)
04e8: movq   $0x0,0x220(%rsp)
04f4: mov    %r13,0x18(%rsp)
04f9: mov    %ebp,0x14(%rsp)
04fd: movl   $0x0,0x10(%rsp)
0505: lea    0xf0(%rsp),%rdi
050d: lea    0x10(%rsp),%rsi
0512: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0517: lea    RIP_ADDRESS(%rip),%rax
051e: mov    %rax,0x38(%rsp)
0523: lea    RIP_ADDRESS(%rip),%rax
052a: mov    %rax,0x30(%rsp)
052f: mov    0x100(%rsp),%rax
0537: test   %rax,%rax
053a: je     LOCAL+0x563::approx_signal+0x563>
053c: dec    %rax
053f: mov    %rax,0x100(%rsp)
0547: mov    0xf8(%rsp),%rcx
054f: shl    $0x4,%rax
0553: mov    (%rcx,%rax,1),%r12d
0557: mov    0x4(%rcx,%rax,1),%r9d
055c: mov    0x8(%rcx,%rax,1),%r13
0561: jmp    LOCAL+0x5ab::approx_signal+0x5ab>
0563: mov    0x208(%rsp),%rax
056b: test   %rax,%rax
056e: je     LOCAL+0xf9c::approx_signal+0xf9c>
0574: lea    -0x1(%rax),%rdi
0578: mov    %rdi,0x208(%rsp)
0580: cmp    $0x10,%rax
0584: ja     LOCAL+0x11c6::approx_signal+0x11c6>
058a: shl    $0x4,%rdi
058e: lea    0x108(%rsp),%rax
0596: mov    (%rax,%rdi,1),%r12d
059a: mov    0x4(%rax,%rdi,1),%r9d
059f: mov    0x8(%rax,%rdi,1),%r13
05a4: movl   $0xffffffff,(%rax,%rdi,1)
05ab: cmp    $0xffffffff,%r12d
05af: je     LOCAL+0xf9c::approx_signal+0xf9c>
05b5: test   %r14,%r14
05b8: je     LOCAL+0x5c7::approx_signal+0x5c7>
05ba: movzbl 0x10(%r14),%eax
05bf: test   %al,%al
05c1: jne    LOCAL+0xcc0::approx_signal+0xcc0>
05c7: movzbl 0x10(%r15),%eax
05cc: test   %eax,%eax
05ce: jne    LOCAL+0xc56::approx_signal+0xc56>
05d4: mov    (%r15),%rcx
05d7: movabs $0x7fffffffffffffff,%rax
05e1: cmp    %rax,%rcx
05e4: jae    LOCAL+0xc90::approx_signal+0xc90>
05ea: lea    0x1(%rcx),%rax
05ee: mov    %rax,(%r15)
05f1: mov    0x8(%r15),%rdx
05f5: test   %rdx,%rdx
05f8: je     LOCAL+0x62e::approx_signal+0x62e>
05fa: mov    %rdx,%rsi
05fd: cmpb   $0x0,0x20(%rsi)
0601: jne    LOCAL+0xcb0::approx_signal+0xcb0>
0607: mov    0x10(%rsi),%rdi
060b: mov    0x18(%rdi),%rax
060f: nop
0610: test   %rax,%rax
0613: je     LOCAL+0xcb0::approx_signal+0xcb0>
0619: lea    -0x1(%rax),%r8
061d: lock cmpxchg %r8,0x18(%rdi)
0623: jne    LOCAL+0x610::approx_signal+0x610>
0625: mov    0x18(%rsi),%rsi
0629: test   %rsi,%rsi
062c: jne    LOCAL+0x5fd::approx_signal+0x5fd>
062e: mov    %r9d,0xc(%rsp)
0633: mov    %rcx,(%r15)
0636: mov    %r12d,%eax
0639: lea    RIP_ADDRESS(%rip),%rcx
0640: movslq (%rcx,%rax,4),%rax
0644: add    %rcx,%rax
0647: jmp    *%rax
0649: mov    0x0(%r13),%rsi
064d: cmpb   $0x0,0x10(%rsi)
0651: jne    LOCAL+0x660::approx_signal+0x660>
0653: cmpb   $0x1,0x30(%rsi)
0657: lea    RIP_ADDRESS(%rip),%rax
065e: je     LOCAL+0x694::approx_signal+0x694>
0660: mov    0xc(%rsp),%edx
0664: cmp    $0xffefffff,%edx
066a: jle    LOCAL+0x1095::approx_signal+0x1095>
0670: lea    0x388(%rsp),%rdi
0678: call   TARGET<<hyperreal::computable::node::Computable>::cached_at_precision>
067d: cmpq   $0xffffffffffffffff,0x388(%rsp)
0686: lea    0x388(%rsp),%rax
068e: je     LOCAL+0x923::approx_signal+0x923>
0694: lea    0x210(%rsp),%rdi
069c: mov    %rax,%rsi
069f: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
06a4: jmp    LOCAL+0x52f::approx_signal+0x52f>
06a9: lea    0x10(%rsp),%rdi
06ae: lea    0x210(%rsp),%rsi
06b6: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::pop>
06bb: mov    %r13,0x68(%rsp)
06c0: mov    0x10(%rsp),%r12
06c5: cmp    $0xffffffffffffffff,%r12
06c9: je     LOCAL+0x113b::approx_signal+0x113b>
06cf: mov    0x18(%rsp),%r13
06d4: lea    0x29(%rsp),%rax
06d9: movups -0x9(%rax),%xmm0
06dd: movaps %xmm0,0x350(%rsp)
06e5: lea    0x10(%rsp),%rdi
06ea: lea    0x210(%rsp),%rsi
06f2: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::pop>
06f7: cmpq   $0xffffffffffffffff,0x10(%rsp)
06fd: je     LOCAL+0x1161::approx_signal+0x1161>
0703: movups 0x10(%rsp),%xmm0
0708: movups 0x20(%rsp),%xmm1
070d: movaps %xmm1,0x370(%rsp)
0715: movaps %xmm0,0x360(%rsp)
071d: mov    %r12,0x10(%rsp)
0722: mov    %r13,0x18(%rsp)
0727: movaps 0x350(%rsp),%xmm0
072f: lea    0x29(%rsp),%rax
0734: movups %xmm0,-0x9(%rax)
0738: lea    0x48(%rsp),%rbp
073d: mov    %rbp,%rdi
0740: lea    0x360(%rsp),%rsi
0748: lea    0x10(%rsp),%rdx
074d: call   TARGET<<num_bigint::bigint::BigInt as core::ops::arith::Add>::add>
0752: lea    0x330(%rsp),%r13
075a: mov    %r13,%rdi
075d: mov    %rbp,%rsi
0760: mov    $0xfffffffe,%edx
0765: call   TARGET<hyperreal::computable::node::scale>
076a: movzbl 0x348(%rsp),%r12d
0773: mov    %rbp,%rdi
0776: mov    %r13,%rsi
0779: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
077e: mov    0x58(%rsp),%rax
0783: mov    %rax,0x20(%rsp)
0788: movups 0x48(%rsp),%xmm0
078d: movaps %xmm0,0x10(%rsp)
0792: mov    %r12b,0x28(%rsp)
0797: mov    0x68(%rsp),%rdi
079c: mov    %r14,%rsi
079f: mov    0xc(%rsp),%edx
07a3: lea    0x10(%rsp),%rcx
07a8: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
07ad: cmp    $0xff,%al
07af: jne    LOCAL+0x105e::approx_signal+0x105e>
07b5: lea    0x210(%rsp),%rdi
07bd: mov    %r13,%rsi
07c0: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
07c5: jmp    LOCAL+0x52f::approx_signal+0x52f>
07ca: lea    0x10(%rsp),%rdi
07cf: lea    0x210(%rsp),%rsi
07d7: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::pop>
07dc: cmpq   $0xffffffffffffffff,0x10(%rsp)
07e2: je     LOCAL+0x111c::approx_signal+0x111c>
07e8: movups 0x10(%rsp),%xmm0
07ed: movups 0x20(%rsp),%xmm1
07f2: movaps %xmm1,0xa0(%rsp)
07fa: movaps %xmm0,0x90(%rsp)
0802: movzbl 0xa8(%rsp),%r12d
080b: lea    0x48(%rsp),%rdi
0810: lea    0x90(%rsp),%rsi
0818: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
081d: mov    0xc(%rsp),%edx
0821: mov    0x58(%rsp),%rax
0826: mov    %rax,0x20(%rsp)
082b: movups 0x48(%rsp),%xmm0
0830: movaps %xmm0,0x10(%rsp)
0835: mov    %r12b,0x28(%rsp)
083a: mov    %r13,%rdi
083d: mov    %r14,%rsi
0840: lea    0x10(%rsp),%rcx
0845: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
084a: cmp    $0xff,%al
084c: jne    LOCAL+0x101a::approx_signal+0x101a>
0852: lea    0x210(%rsp),%rdi
085a: lea    0x90(%rsp),%rsi
0862: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
0867: jmp    LOCAL+0x52f::approx_signal+0x52f>
086c: lea    0x10(%rsp),%rdi
0871: lea    0x210(%rsp),%rsi
0879: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::pop>
087e: cmpq   $0xffffffffffffffff,0x10(%rsp)
0884: je     LOCAL+0x115a::approx_signal+0x115a>
088a: mov    0x20(%rsp),%rax
088f: mov    %rax,0x80(%rsp)
0897: movups 0x10(%rsp),%xmm0
089c: movaps %xmm0,0x70(%rsp)
08a1: lea    0x29(%rsp),%rcx
08a6: mov    (%rcx),%eax
08a8: mov    $0x2,%r12b
08ab: sub    0x28(%rsp),%r12b
08b0: mov    0x3(%rcx),%ecx
08b3: lea    0x89(%rsp),%rdx
08bb: mov    %ecx,0x3(%rdx)
08be: mov    %eax,(%rdx)
08c0: mov    %r12b,0x88(%rsp)
08c8: lea    0x48(%rsp),%rdi
08cd: lea    0x70(%rsp),%rsi
08d2: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
08d7: mov    0xc(%rsp),%edx
08db: mov    0x58(%rsp),%rax
08e0: mov    %rax,0x20(%rsp)
08e5: movups 0x48(%rsp),%xmm0
08ea: movaps %xmm0,0x10(%rsp)
08ef: mov    %r12b,0x28(%rsp)
08f4: mov    %r13,%rdi
08f7: mov    %r14,%rsi
08fa: lea    0x10(%rsp),%rcx
08ff: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
0904: cmp    $0xff,%al
0906: jne    LOCAL+0x103f::approx_signal+0x103f>
090c: lea    0x210(%rsp),%rdi
0914: lea    0x70(%rsp),%rsi
0919: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
091e: jmp    LOCAL+0x52f::approx_signal+0x52f>
0923: lea    0x10(%rsp),%rdi
0928: mov    %r13,%rsi
092b: mov    0x40(%rsp),%rdx
0930: mov    0xc(%rsp),%ecx
0934: call   TARGET<<hyperreal::computable::node::Computable>::cached_quadratic_tower_approximation>
0939: mov    0x10(%rsp),%r12
093e: cmp    $0xfffffffffffffffe,%r12
0942: je     LOCAL+0x9ef::approx_signal+0x9ef>
0948: cmp    $0xffffffffffffffff,%r12
094c: je     LOCAL+0x10a6::approx_signal+0x10a6>
0952: mov    %r13,%rbp
0955: movzbl 0x18(%rsp),%eax
095a: lea    0x29(%rsp),%rdx
095f: mov    -0x1(%rdx),%rcx
0963: lea    0xb9(%rsp),%rsi
096b: mov    %rcx,0xf(%rsi)
096f: movups -0x10(%rdx),%xmm0
0973: movups %xmm0,(%rsi)
0976: mov    %r12,0xb0(%rsp)
097e: mov    %al,0xb8(%rsp)
0985: movzbl 0xc8(%rsp),%r13d
098e: lea    0x48(%rsp),%rdi
0993: lea    0xb0(%rsp),%rsi
099b: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
09a0: mov    0x58(%rsp),%rax
09a5: mov    %rax,0x20(%rsp)
09aa: movups 0x48(%rsp),%xmm0
09af: movaps %xmm0,0x10(%rsp)
09b4: mov    %r13b,0x28(%rsp)
09b9: mov    %rbp,%rdi
09bc: mov    %r14,%rsi
09bf: mov    0xc(%rsp),%edx
09c3: lea    0x10(%rsp),%rcx
09c8: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
09cd: cmp    $0xff,%al
09cf: jne    LOCAL+0x10b3::approx_signal+0x10b3>
09d5: lea    0x210(%rsp),%rdi
09dd: lea    0xb0(%rsp),%rsi
09e5: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
09ea: jmp    LOCAL+0x52f::approx_signal+0x52f>
09ef: mov    0x0(%r13),%r12
09f3: movzbl 0x10(%r12),%eax
09f9: cmp    $0xa,%eax
09fc: je     LOCAL+0xb26::approx_signal+0xb26>
0a02: cmp    $0x5,%eax
0a05: je     LOCAL+0xa67::approx_signal+0xa67>
0a07: cmp    $0x4,%eax
0a0a: jne    LOCAL+0xb90::approx_signal+0xb90>
0a10: mov    %r13,0x18(%rsp)
0a15: mov    0xc(%rsp),%eax
0a19: mov    %eax,0x14(%rsp)
0a1d: movl   $0x1,0x10(%rsp)
0a25: lea    0xf0(%rsp),%rdi
0a2d: lea    0x10(%rsp),%rsi
0a32: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0a37: add    $0x18,%r12
0a3b: mov    %r12,0x18(%rsp)
0a40: mov    0xc(%rsp),%eax
0a44: mov    %eax,0x14(%rsp)
0a48: movl   $0x0,0x10(%rsp)
0a50: lea    0xf0(%rsp),%rdi
0a58: lea    0x10(%rsp),%rsi
0a5d: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0a62: jmp    LOCAL+0x52f::approx_signal+0x52f>
0a67: mov    %r13,0x18(%rsp)
0a6c: mov    0xc(%rsp),%eax
0a70: mov    %eax,0x14(%rsp)
0a74: movl   $0x2,0x10(%rsp)
0a7c: lea    0xf0(%rsp),%rdi
0a84: lea    0x10(%rsp),%rsi
0a89: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0a8e: lea    0x28(%r12),%rdx
0a93: lea    0x18(%r12),%rbp
0a98: mov    0x28(%r12),%rax
0a9d: mov    0x38(%rax),%r13
0aa1: shr    $0x10,%r13d
0aa5: mov    0x18(%r12),%rax
0aaa: mov    0x38(%rax),%r12
0aae: shr    $0x10,%r12d
0ab2: mov    0xc(%rsp),%ecx
0ab6: add    $0xfffffffe,%ecx
0ab9: cmp    %r12w,%r13w
0abd: mov    %rdx,0x68(%rsp)
0ac2: mov    %rdx,%rax
0ac5: cmovg  %rbp,%rax
0ac9: mov    %rax,0x18(%rsp)
0ace: mov    %ecx,0xc(%rsp)
0ad2: mov    %ecx,0x14(%rsp)
0ad6: movl   $0x0,0x10(%rsp)
0ade: lea    0xf0(%rsp),%rdi
0ae6: lea    0x10(%rsp),%rsi
0aeb: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0af0: cmp    %r12w,%r13w
0af4: cmovg  0x68(%rsp),%rbp
0afa: mov    %rbp,0x18(%rsp)
0aff: mov    0xc(%rsp),%eax
0b03: mov    %eax,0x14(%rsp)
0b07: movl   $0x0,0x10(%rsp)
0b0f: lea    0xf0(%rsp),%rdi
0b17: lea    0x10(%rsp),%rsi
0b1c: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0b21: jmp    LOCAL+0x52f::approx_signal+0x52f>
0b26: mov    %r13,0x18(%rsp)
0b2b: mov    0xc(%rsp),%eax
0b2f: mov    %eax,0x14(%rsp)
0b33: movl   $0x3,0x10(%rsp)
0b3b: lea    0xf0(%rsp),%rdi
0b43: lea    0x10(%rsp),%rsi
0b48: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0b4d: mov    0xc(%rsp),%eax
0b51: sub    0x14(%r12),%eax
0b56: mov    %eax,0xc(%rsp)
0b5a: jo     LOCAL+0x11ab::approx_signal+0x11ab>
0b60: add    $0x18,%r12
0b64: mov    %r12,0x18(%rsp)
0b69: mov    0xc(%rsp),%eax
0b6d: mov    %eax,0x14(%rsp)
0b71: movl   $0x0,0x10(%rsp)
0b79: lea    0xf0(%rsp),%rdi
0b81: lea    0x10(%rsp),%rsi
0b86: call   TARGET<<hyperreal::computable::node::InlineStack<<hyperreal::computable::node::Computable>::approx_signal::Frame, 16>>::push>
0b8b: jmp    LOCAL+0x52f::approx_signal+0x52f>
0b90: add    $0x10,%r12
0b94: lea    0x10(%rsp),%rdi
0b99: mov    %r12,%rsi
0b9c: mov    0x40(%rsp),%rdx
0ba1: mov    0xc(%rsp),%ecx
0ba5: call   TARGET<<hyperreal::computable::approximation::Approximation>::approximate>
0baa: mov    0x10(%rsp),%r12
0baf: movzbl 0x18(%rsp),%eax
0bb4: cmp    $0xffffffffffffffff,%r12
0bb8: je     LOCAL+0x10f7::approx_signal+0x10f7>
0bbe: mov    %r13,%rbp
0bc1: lea    0x29(%rsp),%rdx
0bc6: mov    -0x1(%rdx),%rcx
0bca: lea    0xd9(%rsp),%rsi
0bd2: mov    %rcx,0xf(%rsi)
0bd6: movups -0x10(%rdx),%xmm0
0bda: movups %xmm0,(%rsi)
0bdd: mov    %r12,0xd0(%rsp)
0be5: mov    %al,0xd8(%rsp)
0bec: movzbl 0xe8(%rsp),%r13d
0bf5: lea    0x48(%rsp),%rdi
0bfa: lea    0xd0(%rsp),%rsi
0c02: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
0c07: mov    0x58(%rsp),%rax
0c0c: mov    %rax,0x20(%rsp)
0c11: movups 0x48(%rsp),%xmm0
0c16: movaps %xmm0,0x10(%rsp)
0c1b: mov    %r13b,0x28(%rsp)
0c20: mov    %rbp,%rdi
0c23: mov    %r14,%rsi
0c26: mov    0xc(%rsp),%edx
0c2a: lea    0x10(%rsp),%rcx
0c2f: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
0c34: cmp    $0xff,%al
0c36: jne    LOCAL+0x10ff::approx_signal+0x10ff>
0c3c: lea    0x210(%rsp),%rdi
0c44: lea    0xd0(%rsp),%rsi
0c4c: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::push>
0c51: jmp    LOCAL+0x52f::approx_signal+0x52f>
0c56: cmp    $0x2,%eax
0c59: je     LOCAL+0x10e5::approx_signal+0x10e5>
0c5f: mov    %r9d,%ebp
0c62: mov    %r15,%rdi
0c65: lea    RIP_ADDRESS(%rip),%rsi
0c6c: call   *RIP_ADDRESS(%rip)
0c72: movb   $0x0,0x10(%r15)
0c77: mov    %ebp,%r9d
0c7a: mov    (%r15),%rcx
0c7d: movabs $0x7fffffffffffffff,%rax
0c87: cmp    %rax,%rcx
0c8a: jb     LOCAL+0x5ea::approx_signal+0x5ea>
0c90: lea    RIP_ADDRESS(%rip),%rdi
0c97: call   *RIP_ADDRESS(%rip)
0c9d: jmp    LOCAL+0x11d8::approx_signal+0x11d8>
0ca2: data16 data16 data16 data16 cs nopw 0x0(%rax,%rax,1)
0cb0: movb   $0x1,0x20(%rdx)
0cb4: mov    0x18(%rdx),%rdx
0cb8: test   %rdx,%rdx
0cbb: jne    LOCAL+0xcb0::approx_signal+0xcb0>
0cbd: mov    %rcx,(%r15)
0cc0: movb   $0xc,0x8(%rbx)
0cc4: movq   $0xffffffffffffffff,(%rbx)
0ccb: lea    0x210(%rsp),%rdi
0cd3: call   TARGET<core::ptr::drop_glue::<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>>
0cd8: mov    0xf0(%rsp),%rsi
0ce0: test   %rsi,%rsi
0ce3: je     LOCAL+0x1db::approx_signal+0x1db>
0ce9: mov    0xf8(%rsp),%rdi
0cf1: shl    $0x4,%rsi
0cf5: jmp    LOCAL+0xdb1::approx_signal+0xdb1>
0cfa: test   %al,%al
0cfc: je     LOCAL+0xdc9::approx_signal+0xdc9>
0d02: xor    %esi,%esi
0d04: lea    0x10(%rsp),%rdi
0d09: call   TARGET<<num_bigint::bigint::BigInt as core::convert::From<i64>>::from>
0d0e: add    $0x38,%r12
0d12: mov    0x28(%rsp),%esi
0d16: mov    %r12,%rdi
0d19: call   TARGET<<hyperreal::computable::node::AtomicFacts>::publish_exact_sign>
0d1e: lea    0xf0(%rsp),%r15
0d26: lea    0x10(%rsp),%rsi
0d2b: mov    %r15,%rdi
0d2e: mov    %ebp,%edx
0d30: call   TARGET<hyperreal::computable::node::scale_at_precision>
0d35: movzbl 0x108(%rsp),%r12d
0d3e: lea    0x48(%rsp),%rdi
0d43: mov    %r15,%rsi
0d46: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
0d4b: mov    0x58(%rsp),%rax
0d50: mov    %rax,0x220(%rsp)
0d58: movups 0x48(%rsp),%xmm0
0d5d: movaps %xmm0,0x210(%rsp)
0d65: mov    %r12b,0x228(%rsp)
0d6d: lea    0x210(%rsp),%rcx
0d75: mov    %r13,%rdi
0d78: mov    %r14,%rsi
0d7b: mov    %ebp,%edx
0d7d: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
0d82: cmp    $0xff,%al
0d84: je     LOCAL+0xf87::approx_signal+0xf87>
0d8a: mov    %al,0x8(%rbx)
0d8d: movq   $0xffffffffffffffff,(%rbx)
0d94: mov    0xf0(%rsp),%rsi
0d9c: test   %rsi,%rsi
0d9f: je     LOCAL+0x1db::approx_signal+0x1db>
0da5: mov    0xf8(%rsp),%rdi
0dad: shl    $0x3,%rsi
0db1: mov    $0x8,%edx
0db6: call   *RIP_ADDRESS(%rip)
0dbc: jmp    LOCAL+0x1db::approx_signal+0x1db>
0dc1: test   %cl,%cl
0dc3: jne    LOCAL+0xd02::approx_signal+0xd02>
0dc9: movb   $0x2,0x8(%rbx)
0dcd: jmp    LOCAL+0x1d4::approx_signal+0x1d4>
0dd2: movzbl 0x218(%rsp),%eax
0dda: jmp    LOCAL+0xd4::approx_signal+0xd4>
0ddf: lea    0x210(%rsp),%rdi
0de7: mov    0x40(%rsp),%rdx
0dec: mov    %ebp,%ecx
0dee: call   TARGET<<hyperreal::computable::approximation::Approximation>::approximate>
0df3: mov    0x210(%rsp),%r15
0dfb: movzbl 0x218(%rsp),%eax
0e03: cmp    $0xffffffffffffffff,%r15
0e07: je     LOCAL+0xd4::approx_signal+0xd4>
0e0d: mov    0x228(%rsp),%rcx
0e15: mov    %rcx,0x108(%rsp)
0e1d: movups 0x219(%rsp),%xmm0
0e25: movups %xmm0,0xf9(%rsp)
0e2d: mov    %r15,0xf0(%rsp)
0e35: mov    %al,0xf8(%rsp)
0e3c: movzbl 0x108(%rsp),%r12d
0e45: lea    0x10(%rsp),%rdi
0e4a: lea    0xf0(%rsp),%rsi
0e52: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
0e57: mov    0x20(%rsp),%rax
0e5c: mov    %rax,0x220(%rsp)
0e64: movups 0x10(%rsp),%xmm0
0e69: movaps %xmm0,0x210(%rsp)
0e71: mov    %r12b,0x228(%rsp)
0e79: lea    0x210(%rsp),%rcx
0e81: mov    %r13,%rdi
0e84: mov    %r14,%rsi
0e87: mov    %ebp,%edx
0e89: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
0e8e: cmp    $0xff,%al
0e90: je     LOCAL+0xf87::approx_signal+0xf87>
0e96: mov    %al,0x8(%rbx)
0e99: movq   $0xffffffffffffffff,(%rbx)
0ea0: test   %r15,%r15
0ea3: je     LOCAL+0x1db::approx_signal+0x1db>
0ea9: mov    0xf8(%rsp),%rdi
0eb1: shl    $0x3,%r15
0eb5: mov    $0x8,%edx
0eba: mov    %r15,%rsi
0ebd: call   *RIP_ADDRESS(%rip)
0ec3: jmp    LOCAL+0x1db::approx_signal+0x1db>
0ec8: movzbl 0x218(%rsp),%eax
0ed0: mov    0x228(%rsp),%rcx
0ed8: mov    %rcx,0x108(%rsp)
0ee0: movups 0x219(%rsp),%xmm0
0ee8: movups %xmm0,0xf9(%rsp)
0ef0: mov    %r12,0xf0(%rsp)
0ef8: mov    %al,0xf8(%rsp)
0eff: movzbl 0x108(%rsp),%r15d
0f08: lea    0x10(%rsp),%rdi
0f0d: lea    0xf0(%rsp),%rsi
0f15: call   TARGET<<alloc::vec::Vec<u64> as core::clone::Clone>::clone>
0f1a: mov    0x20(%rsp),%rax
0f1f: mov    %rax,0x220(%rsp)
0f27: movups 0x10(%rsp),%xmm0
0f2c: movaps %xmm0,0x210(%rsp)
0f34: mov    %r15b,0x228(%rsp)
0f3c: lea    0x210(%rsp),%rcx
0f44: mov    %r13,%rdi
0f47: mov    %r14,%rsi
0f4a: mov    %ebp,%edx
0f4c: call   TARGET<<hyperreal::computable::node::Computable>::store_cache_value>
0f51: cmp    $0xff,%al
0f53: je     LOCAL+0xf87::approx_signal+0xf87>
0f55: mov    %al,0x8(%rbx)
0f58: movq   $0xffffffffffffffff,(%rbx)
0f5f: test   %r12,%r12
0f62: je     LOCAL+0x1db::approx_signal+0x1db>
0f68: mov    0xf8(%rsp),%rdi
0f70: shl    $0x3,%r12
0f74: mov    $0x8,%edx
0f79: mov    %r12,%rsi
0f7c: call   *RIP_ADDRESS(%rip)
0f82: jmp    LOCAL+0x1db::approx_signal+0x1db>
0f87: movups 0xf0(%rsp),%xmm0
0f8f: movups 0x100(%rsp),%xmm1
0f97: jmp    LOCAL+0x26a::approx_signal+0x26a>
0f9c: lea    0x10(%rsp),%rdi
0fa1: lea    0x210(%rsp),%rsi
0fa9: call   TARGET<<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>::pop>
0fae: cmpq   $0xffffffffffffffff,0x10(%rsp)
0fb4: je     LOCAL+0x117c::approx_signal+0x117c>
0fba: movups 0x10(%rsp),%xmm0
0fbf: movups 0x20(%rsp),%xmm1
0fc4: movups %xmm1,0x10(%rbx)
0fc8: movups %xmm0,(%rbx)
0fcb: jmp    LOCAL+0xccb::approx_signal+0xccb>
0fd0: cmp    $0x1,%eax
0fd3: jne    LOCAL+0x100d::approx_signal+0x100d>
0fd5: lea    RIP_ADDRESS(%rip),%rsi
0fdc: mov    %r15,%rdi
0fdf: call   *RIP_ADDRESS(%rip)
0fe5: movb   $0x0,0x10(%r15)
0fea: movabs $0x7fffffffffffffff,%rax
0ff4: mov    (%r15),%rcx
0ff7: cmp    %rax,%rcx
0ffa: jb     LOCAL+0x6b::approx_signal+0x6b>
1000: lea    RIP_ADDRESS(%rip),%rdi
1007: call   *RIP_ADDRESS(%rip)
100d: lea    RIP_ADDRESS(%rip),%rdi
1014: call   *RIP_ADDRESS(%rip)
101a: mov    %al,0x8(%rbx)
101d: movq   $0xffffffffffffffff,(%rbx)
1024: mov    0x90(%rsp),%rsi
102c: test   %rsi,%rsi
102f: je     LOCAL+0xccb::approx_signal+0xccb>
1035: mov    0x98(%rsp),%rdi
103d: jmp    LOCAL+0x1081::approx_signal+0x1081>
103f: mov    %al,0x8(%rbx)
1042: movq   $0xffffffffffffffff,(%rbx)
1049: mov    0x70(%rsp),%rsi
104e: test   %rsi,%rsi
1051: je     LOCAL+0xccb::approx_signal+0xccb>
1057: mov    0x78(%rsp),%rdi
105c: jmp    LOCAL+0x1081::approx_signal+0x1081>
105e: mov    %al,0x8(%rbx)
1061: movq   $0xffffffffffffffff,(%rbx)
1068: mov    0x330(%rsp),%rsi
1070: test   %rsi,%rsi
1073: je     LOCAL+0xccb::approx_signal+0xccb>
1079: mov    0x338(%rsp),%rdi
1081: shl    $0x3,%rsi
1085: mov    $0x8,%edx
108a: call   *RIP_ADDRESS(%rip)
1090: jmp    LOCAL+0xccb::approx_signal+0xccb>
1095: neg    %edx
1097: setno  %al
109a: add    %al,%al
109c: add    $0xa,%al
109e: mov    %al,0x8(%rbx)
10a1: jmp    LOCAL+0xcc4::approx_signal+0xcc4>
10a6: movzbl 0x18(%rsp),%eax
10ab: mov    %al,0x8(%rbx)
10ae: jmp    LOCAL+0xcc4::approx_signal+0xcc4>
10b3: mov    %al,0x8(%rbx)
10b6: movq   $0xffffffffffffffff,(%rbx)
10bd: test   %r12,%r12
10c0: je     LOCAL+0xccb::approx_signal+0xccb>
10c6: mov    0xb8(%rsp),%rdi
10ce: shl    $0x3,%r12
10d2: mov    $0x8,%edx
10d7: mov    %r12,%rsi
10da: call   *RIP_ADDRESS(%rip)
10e0: jmp    LOCAL+0xccb::approx_signal+0xccb>
10e5: lea    RIP_ADDRESS(%rip),%rdi
10ec: call   *RIP_ADDRESS(%rip)
10f2: jmp    LOCAL+0x11d8::approx_signal+0x11d8>
10f7: mov    %al,0x8(%rbx)
10fa: jmp    LOCAL+0xcc4::approx_signal+0xcc4>
10ff: mov    %al,0x8(%rbx)
1102: movq   $0xffffffffffffffff,(%rbx)
1109: test   %r12,%r12
110c: je     LOCAL+0xccb::approx_signal+0xccb>
1112: mov    0xd8(%rsp),%rdi
111a: jmp    LOCAL+0x10ce::approx_signal+0x10ce>
111c: mov    $0x20,%esi
1121: lea    RIP_ADDRESS(%rip),%rax
1128: mov    %rax,0x30(%rsp)
112d: lea    RIP_ADDRESS(%rip),%rax
1134: mov    %rax,0x38(%rsp)
1139: jmp    LOCAL+0x1199::approx_signal+0x1199>
113b: mov    $0x1b,%esi
1140: lea    RIP_ADDRESS(%rip),%rax
1147: mov    %rax,0x30(%rsp)
114c: lea    RIP_ADDRESS(%rip),%rax
1153: mov    %rax,0x38(%rsp)
1158: jmp    LOCAL+0x1199::approx_signal+0x1199>
115a: mov    $0x20,%esi
115f: jmp    LOCAL+0x1199::approx_signal+0x1199>
1161: lea    RIP_ADDRESS(%rip),%rdi
1168: lea    RIP_ADDRESS(%rip),%rdx
116f: mov    $0x1b,%esi
1174: call   *RIP_ADDRESS(%rip)
117a: jmp    LOCAL+0x11d8::approx_signal+0x11d8>
117c: lea    RIP_ADDRESS(%rip),%rax
1183: mov    %rax,0x38(%rsp)
1188: mov    $0x22,%esi
118d: lea    RIP_ADDRESS(%rip),%rax
1194: mov    %rax,0x30(%rsp)
1199: mov    0x30(%rsp),%rdi
119e: mov    0x38(%rsp),%rdx
11a3: call   *RIP_ADDRESS(%rip)
11a9: jmp    LOCAL+0x11d8::approx_signal+0x11d8>
11ab: movb   $0xa,0x8(%rbx)
11af: jmp    LOCAL+0xcc4::approx_signal+0xcc4>
11b4: lea    RIP_ADDRESS(%rip),%rdx
11bb: mov    $0x4,%esi
11c0: call   *RIP_ADDRESS(%rip)
11c6: lea    RIP_ADDRESS(%rip),%rdx
11cd: mov    $0x10,%esi
11d2: call   *RIP_ADDRESS(%rip)
11d8: ud2
11da: jmp    LOCAL+0x133a::approx_signal+0x133a>
11df: mov    %rax,%rbx
11e2: test   %r12,%r12
11e5: je     LOCAL+0x133d::approx_signal+0x133d>
11eb: mov    0xd8(%rsp),%rdi
11f3: jmp    LOCAL+0x120e::approx_signal+0x120e>
11f5: jmp    LOCAL+0x133a::approx_signal+0x133a>
11fa: mov    %rax,%rbx
11fd: test   %r12,%r12
1200: je     LOCAL+0x133d::approx_signal+0x133d>
1206: mov    0xb8(%rsp),%rdi
120e: shl    $0x3,%r12
1212: mov    $0x8,%edx
1217: jmp    LOCAL+0x132d::approx_signal+0x132d>
121c: jmp    LOCAL+0x133a::approx_signal+0x133a>
1221: jmp    LOCAL+0x133a::approx_signal+0x133a>
1226: jmp    LOCAL+0x133a::approx_signal+0x133a>
122b: jmp    LOCAL+0x1319::approx_signal+0x1319>
1230: mov    %rax,%rbx
1233: mov    0x330(%rsp),%rsi
123b: test   %rsi,%rsi
123e: je     LOCAL+0x133d::approx_signal+0x133d>
1244: mov    0x338(%rsp),%rdi
124c: jmp    LOCAL+0x1287::approx_signal+0x1287>
124e: jmp    LOCAL+0x133a::approx_signal+0x133a>
1253: mov    %rax,%rbx
1256: mov    0x70(%rsp),%rsi
125b: test   %rsi,%rsi
125e: je     LOCAL+0x133d::approx_signal+0x133d>
1264: mov    0x78(%rsp),%rdi
1269: jmp    LOCAL+0x1287::approx_signal+0x1287>
126b: mov    %rax,%rbx
126e: mov    0x90(%rsp),%rsi
1276: test   %rsi,%rsi
1279: je     LOCAL+0x133d::approx_signal+0x133d>
127f: mov    0x98(%rsp),%rdi
1287: shl    $0x3,%rsi
128b: mov    $0x8,%edx
1290: call   *RIP_ADDRESS(%rip)
1296: jmp    LOCAL+0x133d::approx_signal+0x133d>
129b: mov    %rax,%rbx
129e: test   %r15,%r15
12a1: je     LOCAL+0x136e::approx_signal+0x136e>
12a7: mov    0xf8(%rsp),%rdi
12af: shl    $0x3,%r15
12b3: mov    $0x8,%edx
12b8: mov    %r15,%rsi
12bb: jmp    LOCAL+0x1368::approx_signal+0x1368>
12c0: mov    %rax,%rbx
12c3: test   %r12,%r12
12c6: je     LOCAL+0x136e::approx_signal+0x136e>
12cc: mov    0xf8(%rsp),%rdi
12d4: shl    $0x3,%r12
12d8: mov    $0x8,%edx
12dd: mov    %r12,%rsi
12e0: jmp    LOCAL+0x1368::approx_signal+0x1368>
12e5: jmp    LOCAL+0x133a::approx_signal+0x133a>
12e7: mov    %rax,%rbx
12ea: mov    0x10(%rsp),%rsi
12ef: test   %rsi,%rsi
12f2: je     LOCAL+0x136e::approx_signal+0x136e>
12f4: mov    0x18(%rsp),%rdi
12f9: jmp    LOCAL+0x1313::approx_signal+0x1313>
12fb: mov    %rax,%rbx
12fe: mov    0xf0(%rsp),%rsi
1306: test   %rsi,%rsi
1309: je     LOCAL+0x136e::approx_signal+0x136e>
130b: mov    0xf8(%rsp),%rdi
1313: shl    $0x3,%rsi
1317: jmp    LOCAL+0x1363::approx_signal+0x1363>
1319: mov    %rax,%rbx
131c: test   %r12,%r12
131f: je     LOCAL+0x133d::approx_signal+0x133d>
1321: shl    $0x3,%r12
1325: mov    $0x8,%edx
132a: mov    %r13,%rdi
132d: mov    %r12,%rsi
1330: call   *RIP_ADDRESS(%rip)
1336: jmp    LOCAL+0x133d::approx_signal+0x133d>
1338: jmp    LOCAL+0x133a::approx_signal+0x133a>
133a: mov    %rax,%rbx
133d: lea    0x210(%rsp),%rdi
1345: call   TARGET<core::ptr::drop_glue::<hyperreal::computable::node::InlineStack<num_bigint::bigint::BigInt, 8>>>
134a: mov    0xf0(%rsp),%rsi
1352: test   %rsi,%rsi
1355: je     LOCAL+0x136e::approx_signal+0x136e>
1357: mov    0xf8(%rsp),%rdi
135f: shl    $0x4,%rsi
1363: mov    $0x8,%edx
1368: call   *RIP_ADDRESS(%rip)
136e: mov    %rbx,%rdi
1371: call   TARGET<_Unwind_Resume@plt>
